Commit message: UPDATE simple_robot to HEBI

File: urdf/hebi.urdf (robot description, URDF)
Before this commit: robot HEBI, 2 links, 1 joints
Links:
- link base_link: mass 1.0 -> 0.5
